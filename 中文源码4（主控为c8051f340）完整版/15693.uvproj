# Keil uVision project 15693.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: 15693 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: anticollision.c automatic.c communicate.c hardware.c host.c ISO14443.c main.c anticollision.h automatic.h communicate.h globals.h hardware.h host.h ISO14443.h

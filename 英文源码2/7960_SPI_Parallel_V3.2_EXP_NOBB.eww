<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\7060_SPI_Parallel_Firmware_V2.1A.ewp</path>
  </project>
  <batchBuild/>
</workspace>


